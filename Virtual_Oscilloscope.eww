<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ADC_Wave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Triangle_Wave.ewp</path>
  </project>
  <batchBuild/>
</workspace>


